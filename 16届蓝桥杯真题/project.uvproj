# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c digital_tube.c delay.c digital_tube.h delay.h init.c init.h DS18B20.c DS18B20.h uart.c uart.h kbd.c kbd.h iic.c onewire.c iic.h onewire.h AD_DA.c AD_DA.h superwave.c superwave.h kdb_nb.c kbd_nb.h
