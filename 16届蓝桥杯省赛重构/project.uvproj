# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c latch.c latch.h init.c init.h digitaltube.c digitaltube.h delay.c delay.h kbd.c kbd.h ds1302.c iic.c onewire.c ds1302.h iic.h onewire.h ds18b20.c ds18b20.h superwave.c superwave.h AD.c AD.h
